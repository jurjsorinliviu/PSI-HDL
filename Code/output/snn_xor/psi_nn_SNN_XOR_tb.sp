* SPICE Testbench for Psi-NN Verilog-A Module
* Model: SNN_XOR
* Auto-generated by Psi-HDL Framework

.title Psi-NN Neural Network Test

.hdl ./output/snn_xor\psi_nn_SNN_XOR_tb.va

* Power supplies
Vdd vdd 0 DC 5.0
Vss vss 0 DC 0.0

* Input voltage sources (DC sweep will be used)
Vin0 in0 0 DC 0.0
Vin1 in1 0 DC 0.0

* Device under test
XDUT in0 in1 out0 vdd vss psi_nn_SNN_XOR

* Load resistors
Rload0 out0 0 1MEG

* Analysis
* DC sweep to test network response
.dc Vin0 0.0 1.0 0.1 Vin1 0.0 1.0 0.1
.print dc v(in0) v(in1) v(out0)
.control
run
plot v(out0)
.endc

.end
