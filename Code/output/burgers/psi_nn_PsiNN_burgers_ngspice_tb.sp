* ngspice Testbench for Psi-NN Behavioral Subckt (B-sources)
* Model: PsiNN_burgers
* Auto-generated by Psi-HDL Framework

.title Psi-NN Neural Network Test (ngspice)

.include "C:/Users/jurjs/Desktop/PostDoc pmTUC/Papers ideas/PSI-HDL paper/Code/output/burgers/psi_nn_PsiNN_burgers_ngspice_subckt.sp"

* Power supplies
Vdd vdd 0 DC 5.0
Vss vss 0 DC 0.0

* Input voltage sources (DC sweep will be used)
Vin0 in0 0 DC 0.0
Vin1 in1 0 DC 0.0

* Device under test
XDUT in0 in1 out0 vdd vss psi_nn_psinn_burgers

* Load resistors
Rload0 out0 0 1MEG

* Analysis
* DC sweep to test network response
.dc Vin0 -0.9921973717998185 0.9966476021337312 0.1 Vin1 -0.9960171720926037 0.9901011385731344 0.1
.print dc v(in0) v(in1) v(out0)
.end
