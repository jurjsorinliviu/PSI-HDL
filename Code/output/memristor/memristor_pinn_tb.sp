* SPICE Testbench for Memristor PINN Verilog-A Module
* Model: memristor_pinn
* Auto-generated by Ψ-HDL Framework

.title Memristor PINN Test - I-V Hysteresis

.hdl memristor_pinn.va

* Voltage source: triangular wave for hysteresis sweep
* 3 cycles: 0V -> +1.2V -> -0.8V -> 0V
Vin p 0 PWL(
+ 0ns 0V
+ 100ns 1.2V
+ 200ns -0.8V
+ 300ns 0V
+ 400ns 1.2V
+ 500ns -0.8V
+ 600ns 0V
+ 700ns 1.2V
+ 800ns -0.8V
+ 900ns 0V
+ )

* Device under test
XMEM p n memristor_pinn

* Ground reference
Vn n 0 DC 0V

* Analysis
.tran 1ns 900ns

* Output
.print tran v(p) i(Vin) v(XMEM.x_state)
.control
run
set hcopydevtype=postscript
hardcopy memristor_iv.ps v(p) i(Vin)
plot v(p) i(Vin)
plot v(XMEM.x_state)
.endc

* Model parameters (default values from PINN)
* R_on = 1e3 Ω
* R_off = 1e5 Ω
* alpha = 2.0
* tau = 1e-3 s
* V_set = 0.8 V
* V_reset = -0.6 V

.end
